<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>E:\86132\Documents\demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


